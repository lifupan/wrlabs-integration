## conf/distro/Pulsar-Linux.conf
```bitbake
#
# Copyright (C) 2017 Wind River Systems, Inc.
#

require conf/distro/wrlinux.conf
DISTRO = "Pulsar-Linux"

INHERIT += " ota "
```
